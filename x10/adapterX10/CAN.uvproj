# Keil uVision project CAN.uvproj, settings and files
target CAN (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: release +hex
  c flags: Optim=4 OneElfS=1
  c include: .\
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup Code
    ./: STM32F10x.s
  group Source
    ./: main.c
    ./src/: arch.c func.c init.c bitmapOp.c canTxQue.c charQue.c ascii_tab.c crc8.c wdg.c X10Que.c register.c
  group Interrupts
    ./: stm32f10x_it.c
  group Library
    d:/Keil/ARM/RV31/LIB/ST/: STM32F10xR.LIB
  group Documentation
    ./: readme.txt
